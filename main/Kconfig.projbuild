## main/Kconfig.projbuild
```kconfig
menu "DHT11 Configuration"
	config DHT11_GPIO
		int "DHT11 GPIO"
		range 0 46
		default 23
		help
			GPIO number (GPIOxx) to DHT11 DATA.
endmenu
```
